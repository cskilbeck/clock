# Keil uVision project firmware3.uvprojx, settings and files
target firmware3 (6140001::V6.14.1::ARMCLANG)
  device: STM32G030F6Px STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: firmware3 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=6 v6Lto=1 wLevel=3
  c define: STM32G030xx,USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,PREFETCH_ENABLE=1
  c misc: -Wno-deprecated-register -Wno-multichar
  c include: ../Inc;                                       ../Drivers/STM32G0xx_HAL_Driver/Inc;                                       ../Drivers/CMSIS/Device/ST/STM32G0xx/Include;                                       ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32g030xx.s
  group Application/User
    ../Src/: user.cpp segments.cpp main.c stm32g0xx_it.c
    ../Inc/: main.h user.h util.h
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_ll_utils.c stm32g0xx_ll_exti.c stm32g0xx_ll_gpio.c stm32g0xx_ll_adc.c stm32g0xx_ll_dma.c stm32g0xx_ll_rcc.c stm32g0xx_ll_spi.c stm32g0xx_ll_pwr.c stm32g0xx_ll_tim.c stm32g0xx_ll_usart.c
  group Drivers/CMSIS
    ../Src/: system_stm32g0xx.c
software components: CMSIS:CORE 5.4.0
